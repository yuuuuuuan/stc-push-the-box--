# Keil uVision project zongheshiyan.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: zongheshiyan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Code/: main.c Delay.c GPIO.c KeyScan.c Serial2.c LCD12864.c
